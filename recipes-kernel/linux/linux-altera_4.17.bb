LINUX_VERSION = "4.17"

SRCREV = "b7a0b88d86d484cc5461f15ba1098e2e3c3ddc60"

include linux-altera.inc

#from /kraj/meta-altera/recipes-kernel/linux/linux-altera_4.17.bb
#LIC_FILES_CHKSUM = "file://COPYING;md5=bbea815ee2795b2f4230826c0c6b8814" 
